<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>satnogs_fm_demod</value></param>
<param><key>author</key><value>OZ3RF Nick Østergaard</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>AAUSAT4 Decoder</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>AAUSAT4 decoder for Satogs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>2400</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>value</key><value>fsk_deviation_hz</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>baud_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>106850</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-200e3</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>200e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-200e3</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>200e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_modulation_freq</value></param>
<param><key>value</key><value>deviation/2+500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>(1.0/(baud_rate))*(audio_samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>comment</key><value>SDR device 
RX sampling rate</value></param>
<param><key>value</key><value>2.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>comment</key><value>SDR device 
RX sampling rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>taps</value></param>
<param><key>cutoff_freq</key><value>100e3</value></param>
<param><key>gain</key><value>12.0</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>width</key><value>60000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_ax100_decoder</key>
<param><key>id</key><value>variable_ax100_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>crc</key><value>None</value></param>
<param><key>preamble</key><value>[0x55, 0x55, 0x55, 0x55, 0x55]</value></param>
<param><key>preamble_thrsh</key><value>5</value></param>
<param><key>rs</key><value>True</value></param>
<param><key>sync_thrsh</key><value>3</value></param>
<param><key>sync_word</key><value>[0x4F, 0x5A, 0x34, 0x43, 0x55, 0x42]</value></param>
<param><key>value</key><value>'ok'</value></param>
<param><key>whitening</key><value>None</value></param>
</block>
<block>
<key>variable_ieee802_15_4_variant_decoder</key>
<param><key>id</key><value>variable_ieee802_15_4_variant_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>crc</key><value>0</value></param>
<param><key>frame_len</key><value>256</value></param>
<param><key>preamble</key><value>[0x55, 0x55, 0x55, 0x55, 0x55]</value></param>
<param><key>preamble_thrsh</key><value>2</value></param>
<param><key>sync_thrsh</key><value>1</value></param>
<param><key>sync_word</key><value>[0x4F, 0x5A, 0x34, 0x43, 0x55, 0x42]</value></param>
<param><key>value</key><value>'ok'</value></param>
<param><key>var_len</key><value>False</value></param>
<param><key>whitening</key><value>variable_whitening_ccsds_0</value></param>
</block>
<block>
<key>variable_whitening</key>
<param><key>id</key><value>variable_whitening_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'ok'</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>order</key><value>8</value></param>
<param><key>seed</key><value>0x1FF</value></param>
</block>
<block>
<key>variable_whitening_ccsds</key>
<param><key>id</key><value>variable_whitening_ccsds_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>'ok'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate_rx, 125000, 25000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>aausat4_beacon_parser</key>
<param><key>id</key><value>aausat4_beacon_parser_1</value></param>
<param><key>packet_len</key><value>250*8</value></param>
</block>
<block>
<key>aausat_aausat4_beacon_parser</key>
<param><key>id</key><value>aausat_aausat4_beacon_parser_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>aausat_aausat4_fec</key>
<param><key>id</key><value>aausat_aausat4_fec_0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>(2*math.pi*deviation)/audio_samp_rate</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0</value></param>
<param><key>gain</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>satnogs.not_set_antenna</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_bb_gain</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1</value></param>
<param><key>file</key><value>/home/developer/workspace/tmp/aausat4_obs1253917/iq_from_osmocom_source_48000sps_File_Sink.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>fisk</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>audio_samp_rate*10</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ccsds_descrambler</key>
<param><key>id</key><value>ccsds_descrambler_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decoded_data_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/home/developer/workspace/tmp/.satnogs/data/data</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dev_args</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>satnogs.not_set_dev_args</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_xx_0</value></param>
<param><key>access_code</key><value>010011110101101000110100010000110101010101000010</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>1.0</value></param>
<param><key>ted_gain</key><value>0.9</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>0.2</value></param>
<param><key>max_dev</key><value>1</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>samp_per_sym</value></param>
<param><key>ted_type</key><value>digital.TED_ZERO_CROSSING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_correction_per_sec</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enable_iq_dump</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>fec_generic_decoder</key>
<param><key>id</key><value>fec_generic_decoder_0</value></param>
<param><key>decoder</key><value>decoder_variable</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>test.ogg</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_if_gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/iq.dat</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>comment</key><value>To avoid the SDR carrier at the DC
we shift the LO a little further</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>comment</key><value>To avoid the SDR carrier at the DC
we shift the LO a little further</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>106850</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>comment</key><value>Using the Carson bandwidth rule for filter width:
width = 2*(deviation + max_modulation_freq).
For the majority of FM transmissions we can expect
max_modulation_freq = 3000</value></param>
<param><key>cutoff_freq</key><value>max_modulation_freq*5</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
<param><key>width</key><value>3000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>fsk_deviation_hz</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
<param><key>width</key><value>fsk_deviation_hz</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate_rx/125</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Quadrature Demod Low Pass Filtered"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>audio_samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Correlate Access Code Output"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>audio_samp_rate</value></param>
<param><key>tr_delay</key><value>0.0005</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"syncword"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Before Syncword Detection"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>audio_samp_rate</value></param>
<param><key>tr_delay</key><value>0.0005</value></param>
<param><key>tr_tag</key><value>"syncword"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"Symbol Sync Output"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>audio_samp_rate</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>audio_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>audio_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_rf_gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rigctl_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4532</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>437.424e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_sdr_device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>airspy</value></param>
</block>
<block>
<key>satellites_decode_rs</key>
<param><key>id</key><value>satellites_decode_rs_0</value></param>
<param><key>basis</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>satellites_decode_rs_general</key>
<param><key>id</key><value>satellites_decode_rs_general_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gfpoly</key><value></value></param>
<param><key>fcr</key><value></value></param>
<param><key>nroots</key><value></value></param>
<param><key>prim</key><value></value></param>
<param><key>verbose</key><value></value></param>
</block>
<block>
<key>satellites_nusat_decoder</key>
<param><key>id</key><value>satellites_nusat_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>satellites_print_header</key>
<param><key>id</key><value>satellites_print_header_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>satellites_rscode_decoder</key>
<param><key>id</key><value>satellites_rscode_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>npar</key><value></value></param>
</block>
<block>
<key>satnogs_frame_acquisition</key>
<param><key>id</key><value>satnogs_frame_acquisition_0</value></param>
<param><key>crc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_len</key><value>256</value></param>
<param><key>preamble</key><value>[0x55, 0x55, 0x55, 0x55]</value></param>
<param><key>frame_size_field_len</key><value>1</value></param>
<param><key>max_frame_len</key><value>2048</value></param>
<param><key>preamble_thrsh</key><value>4</value></param>
<param><key>sync_thrsh</key><value>3</value></param>
<param><key>sync_word</key><value>[0x4F, 0x5A, 0x34, 0x43, 0x55, 0x42, 0x59]</value></param>
<param><key>variant</key><value>0</value></param>
<param><key>whitening</key><value>variable_whitening_0</value></param>
</block>
<block>
<key>satnogs_frame_decoder</key>
<param><key>id</key><value>satnogs_frame_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>decoder_object</key><value>variable_ax100_decoder_0</value></param>
<param><key>itype</key><value>byte</value></param>
</block>
<block>
<key>satnogs_frame_file_sink</key>
<param><key>id</key><value>satnogs_frame_file_sink_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>output_type</key><value>0</value></param>
<param><key>prefix_name</key><value>decoded_data_file_path</value></param>
</block>
<block>
<key>satnogs_frame_file_sink</key>
<param><key>id</key><value>satnogs_frame_file_sink_0_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>output_type</key><value>0</value></param>
<param><key>prefix_name</key><value>decoded_data_file_path</value></param>
</block>
<block>
<key>satnogs_frame_file_sink</key>
<param><key>id</key><value>satnogs_frame_file_sink_0_1_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>output_type</key><value>0</value></param>
<param><key>prefix_name</key><value>decoded_data_file_path</value></param>
</block>
<block>
<key>satnogs_frame_file_sink</key>
<param><key>id</key><value>satnogs_frame_file_sink_0_1_0_1_0</value></param>
<param><key>output_type</key><value>0</value></param>
<param><key>prefix_name</key><value>decoded_data_file_path</value></param>
</block>
<block>
<key>satnogs_ogg_encoder</key>
<param><key>id</key><value>satnogs_ogg_encoder_0</value></param>
<param><key>filename</key><value>file_path</value></param>
<param><key>quality</key><value>1.0</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
</block>
<block>
<key>satnogs_u8vector_to_pmt_blobby</key>
<param><key>id</key><value>satnogs_u8vector_to_pmt_blobby_0</value></param>
<param><key>input_arg</key><value>foo</value></param>
</block>
<block>
<key>satnogs_udp_msg_sink</key>
<param><key>id</key><value>satnogs_udp_msg_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>addr</key><value>udp_IP</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>udp_port</value></param>
</block>
<block>
<key>satnogs_udp_msg_sink</key>
<param><key>id</key><value>satnogs_udp_msg_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>addr</key><value>udp_IP</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>udp_port</value></param>
</block>
<block>
<key>satnogs_waterfall_sink</key>
<param><key>id</key><value>satnogs_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>filename</key><value>waterfall_file_path</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>pps</key><value>10</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
</block>
<block>
<key>sync_to_pdu</key>
<param><key>id</key><value>sync_to_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>packlen</key><value>40</value></param>
<param><key>threshold</key><value>1</value></param>
<param><key>sync</key><value>"010011110101101000110100010000110101010101000010"</value></param>
</block>
<block>
<key>sync_to_pdu_packed</key>
<param><key>id</key><value>sync_to_pdu_packed_0</value></param>
<param><key>packlen</key><value>251</value></param>
<param><key>threshold</key><value>1</value></param>
<param><key>sync</key><value>"010011110101101000110100010000110101010101000010"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udp_IP</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>127.0.0.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udp_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16887</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>waterfall_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/waterfall.dat</value></param>
</block>
<connection><source_block_id>aausat_aausat4_fec_0</source_block_id><sink_block_id>aausat_aausat4_beacon_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>aausat_aausat4_fec_0</source_block_id><sink_block_id>blocks_message_debug_1_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>aausat_aausat4_fec_0</source_block_id><sink_block_id>satellites_print_header_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>aausat_aausat4_fec_0</source_block_id><sink_block_id>satnogs_u8vector_to_pmt_blobby_0</sink_block_id><source_key>out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>satnogs_ogg_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>satnogs_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_char_to_float_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>satnogs_frame_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>sync_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>sync_to_pdu_packed_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>aausat4_beacon_parser_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>blocks_char_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_xx_0</source_block_id><sink_block_id>satnogs_frame_acquisition_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>satnogs_frame_acquisition_0</source_block_id><sink_block_id>satnogs_frame_file_sink_0_1_0_0</sink_block_id><source_key>out</source_key><sink_key>frame</sink_key></connection>
<connection><source_block_id>satnogs_frame_acquisition_0</source_block_id><sink_block_id>satnogs_udp_msg_sink_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_frame_decoder_0</source_block_id><sink_block_id>satellites_decode_rs_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_frame_decoder_0</source_block_id><sink_block_id>satnogs_frame_file_sink_0_1_0_1</sink_block_id><source_key>out</source_key><sink_key>frame</sink_key></connection>
<connection><source_block_id>satnogs_u8vector_to_pmt_blobby_0</source_block_id><sink_block_id>blocks_message_debug_1_0_0</sink_block_id><source_key>msg_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>satnogs_u8vector_to_pmt_blobby_0</source_block_id><sink_block_id>satnogs_frame_file_sink_0_1_0_1_0</sink_block_id><source_key>msg_out</source_key><sink_key>frame</sink_key></connection>
<connection><source_block_id>sync_to_pdu_0</source_block_id><sink_block_id>ccsds_descrambler_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sync_to_pdu_packed_0</source_block_id><sink_block_id>aausat_aausat4_fec_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sync_to_pdu_packed_0</source_block_id><sink_block_id>satnogs_frame_file_sink_0_1_0</sink_block_id><source_key>out</source_key><sink_key>frame</sink_key></connection>
<connection><source_block_id>sync_to_pdu_packed_0</source_block_id><sink_block_id>satnogs_udp_msg_sink_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
