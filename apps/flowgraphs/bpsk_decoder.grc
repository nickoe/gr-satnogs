<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>satnogs_bpsk_decoder</value></param>
<param><key>author</key><value>Patrick Dohmen, DL4PD</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>A BPSK decoder block for gr-satnogs</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>BPSK Decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>alpha</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>value</key><value>5000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filt_mode</value></param>
<param><key>comment</key><value>Filtershape:

Use the following values for different filter shapes

Sharp: 0.1
Normal: 0.2
Soft: 0.5</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(samp_per_sym), 0.35, 11*samp_per_sym*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>comment</key><value>SDR device 
TX sampling rate</value></param>
<param><key>value</key><value>satnogs.hw_rx_settings[rx_sdr_device]['samp_rate']</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>taps</value></param>
<param><key>cutoff_freq</key><value>100e3</value></param>
<param><key>gain</key><value>12.0</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>width</key><value>60000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate_rx, 125000, 25000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>0.01</value></param>
<param><key>decay_rate</key><value>0.001</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>attack_rate</key><value>0.01</value></param>
<param><key>decay_rate</key><value>0.001</value></param>
<param><key>gain</key><value>0.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>0.015</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>cw_offset/1200.0*baudrate</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>satnogs.not_set_antenna</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baudrate</value></param>
<param><key>label</key><value>baudrate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_bb_gain</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_1</value></param>
<param><key>comment</key><value>We get:
 - 250 kHz input sampling rate (samp_rate_rx/filter_rate) from first stage
 - 48 kHz output sampling rate</value></param>
<param><key>decim</key><value>int(samp_rate_rx/(samp_rate_rx/filter_rate))</value></param>
<param><key>interp</key><value>audio_samp_rate</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_1_0</value></param>
<param><key>comment</key><value>We get:
 - 48 kHz input sampling rate
 - 12 kHz output sampling rate</value></param>
<param><key>decim</key><value>48000</value></param>
<param><key>interp</key><value>max(12000, int(3*(1+alpha)*baudrate))</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cw_offset</value></param>
<param><key>comment</key><value>The CW offset shifts the carrier from 0 Hz to a
frequency that corresponds to the CW audio
tone. This tone is typically 500-800 Hz.</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decoded_data_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/.satnogs/data/data</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dev_args</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>satnogs.not_set_dev_args</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0_0_0</value></param>
<param><key>w</key><value>0.063</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>0.063</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>samp_per_sym</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>doppler_correction_per_sec</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>enable_iq_dump</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>test.ogg</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>lo_offset</value></param>
<param><key>decim</key><value>int(samp_rate_rx/filter_rate)</value></param>
<param><key>samp_rate</key><value>samp_rate_rx</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>center_freq</key><value>cw_offset/1200.0*baudrate</value></param>
<param><key>decim</key><value>audio_samp_rate/(samp_per_sym*baudrate)</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, audio_samp_rate, (1+alpha)*baudrate, (1+alpha)*baudrate*filt_mode)</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_if_gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/iq.dat</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>comment</key><value>To avoid the SDR carrier at the DC
we shift the LO a little further</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>(1+alpha)*baudrate</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
<param><key>width</key><value>((1+alpha)*baudrate)*filt_mode</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>satnogs.handle_rx_antenna(rx_sdr_device, antenna)</value></param>
<param><key>bb_gain0</key><value>satnogs.handle_rx_bb_gain(rx_sdr_device, bb_gain)</value></param>
<param><key>bw0</key><value>samp_rate_rx</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>rx_freq - lo_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>satnogs.handle_rx_if_gain(rx_sdr_device, if_gain)</value></param>
<param><key>gain0</key><value>satnogs.handle_rx_rf_gain(rx_sdr_device, rf_gain)</value></param>
<param><key>args</key><value>satnogs.handle_rx_dev_args(rx_sdr_device, dev_args)</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_rx</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>satnogs.not_set_rx_rf_gain</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rigctl_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4532</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_sdr_device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtlsdr</value></param>
</block>
<block>
<key>satnogs_ax25_decoder_bm</key>
<param><key>id</key><value>satnogs_ax25_decoder_bm_0</value></param>
<param><key>descrambling</key><value>True</value></param>
<param><key>max_frame_len</key><value>1024</value></param>
<param><key>promisc</key><value>True</value></param>
<param><key>addr</key><value>'GND'</value></param>
<param><key>ssid</key><value>0</value></param>
</block>
<block>
<key>satnogs_ax25_decoder_bm</key>
<param><key>id</key><value>satnogs_ax25_decoder_bm_0_0</value></param>
<param><key>descrambling</key><value>False</value></param>
<param><key>max_frame_len</key><value>1024</value></param>
<param><key>promisc</key><value>True</value></param>
<param><key>addr</key><value>'GND'</value></param>
<param><key>ssid</key><value>0</value></param>
</block>
<block>
<key>satnogs_coarse_doppler_correction_cc</key>
<param><key>id</key><value>satnogs_coarse_doppler_correction_cc_0</value></param>
<param><key>sampling_rate</key><value>samp_rate_rx</value></param>
<param><key>target_freq</key><value>rx_freq</value></param>
</block>
<block>
<key>satnogs_doppler_correction_cc</key>
<param><key>id</key><value>satnogs_doppler_correction_cc_0</value></param>
<param><key>corrections_per_sec</key><value>1000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sampling_rate</key><value>samp_rate_rx</value></param>
<param><key>target_freq</key><value>rx_freq</value></param>
</block>
<block>
<key>satnogs_frame_file_sink</key>
<param><key>id</key><value>satnogs_frame_file_sink_0_1_0</value></param>
<param><key>output_type</key><value>0</value></param>
<param><key>prefix_name</key><value>decoded_data_file_path</value></param>
</block>
<block>
<key>satnogs_iq_sink</key>
<param><key>id</key><value>satnogs_iq_sink_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>filename</key><value>iq_file_path</value></param>
<param><key>scale</key><value>32767</value></param>
<param><key>status</key><value>enable_iq_dump</value></param>
</block>
<block>
<key>satnogs_ogg_encoder</key>
<param><key>id</key><value>satnogs_ogg_encoder_0</value></param>
<param><key>filename</key><value>file_path</value></param>
<param><key>quality</key><value>1.0</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
</block>
<block>
<key>satnogs_tcp_rigctl_msg_source</key>
<param><key>id</key><value>satnogs_tcp_rigctl_msg_source_0</value></param>
<param><key>addr</key><value>"172.28.1.2"</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>mode</key><value>False</value></param>
<param><key>port</key><value>rigctl_port</value></param>
<param><key>interval</key><value>1000/doppler_correction_per_sec</value></param>
</block>
<block>
<key>satnogs_udp_msg_sink</key>
<param><key>id</key><value>satnogs_udp_msg_sink_0_0</value></param>
<param><key>addr</key><value>udp_IP</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>udp_port</value></param>
</block>
<block>
<key>satnogs_waterfall_sink</key>
<param><key>id</key><value>satnogs_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>filename</key><value>waterfall_file_path</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>pps</key><value>10</value></param>
<param><key>samp_rate</key><value>max(12000, int(3*(1+alpha)*baudrate))</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udp_IP</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>127.0.0.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>udp_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16887</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>waterfall_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/waterfall.dat</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>blks2_rational_resampler_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>satnogs_iq_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1_0</source_block_id><sink_block_id>satnogs_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>satnogs_ogg_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>satnogs_ax25_decoder_bm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>satnogs_ax25_decoder_bm_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_ax25_decoder_bm_0</source_block_id><sink_block_id>satnogs_frame_file_sink_0_1_0</sink_block_id><source_key>pdu</source_key><sink_key>frame</sink_key></connection>
<connection><source_block_id>satnogs_ax25_decoder_bm_0</source_block_id><sink_block_id>satnogs_udp_msg_sink_0_0</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_ax25_decoder_bm_0_0</source_block_id><sink_block_id>satnogs_frame_file_sink_0_1_0</sink_block_id><source_key>pdu</source_key><sink_key>frame</sink_key></connection>
<connection><source_block_id>satnogs_ax25_decoder_bm_0_0</source_block_id><sink_block_id>satnogs_udp_msg_sink_0_0</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satnogs_coarse_doppler_correction_cc_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_doppler_correction_cc_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satnogs_tcp_rigctl_msg_source_0</source_block_id><sink_block_id>satnogs_coarse_doppler_correction_cc_0</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>satnogs_tcp_rigctl_msg_source_0</source_block_id><sink_block_id>satnogs_doppler_correction_cc_0</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
</flow_graph>
